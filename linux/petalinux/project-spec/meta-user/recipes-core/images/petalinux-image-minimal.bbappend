do_rootfs[depends] += "gdk-pixbuf-native:do_populate_sysroot gtk+3-native:do_populate_sysroot"
